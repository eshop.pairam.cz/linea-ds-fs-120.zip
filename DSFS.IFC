Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: DSFS.IFC
Time: 2017-07-06T07:37:56
Written by: SwIFC
Made in: SolidWorks 2017

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DSFS
In: Default Storey
PredefinedType: ELEMENT
